# Keil uVision project FreeRTOS_demo.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,SYSTEM_SUPPORT_OS
  c include: .\Libraries\FWlib\inc;.\User\bsp;.\Libraries\CMSIS;.\User;.\FreeRTOS_CORE;.\FreeRTOS_CORE\include;.\FreeRTOS_CORE\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
    ./User/bsp/: bsp_conf.h
  group FWLIB
    ./Libraries/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group FreeRTOS_CORE
    ./FreeRTOS_CORE/: list.c queue.c tasks.c croutine.c event_groups.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS_CORE/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS_CORE/portable/MemMang/: heap_4.c
  group BSP
    ./User/bsp/: bsp_usart1.c bsp_led.c sys_delay.c
